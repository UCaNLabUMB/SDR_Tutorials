options:
  parameters:
    author: UCaN Lab
    generate_options: qt_gui
    id: Remote_Control_02_RX
    output_language: python
    title: 'GR Tutorial: ZMQ'
  states: {}

blocks:
- name: AVG_LEN
  id: variable
  parameters:
    value: '2500'
  states: {}
- name: fc_rx
  id: variable_qtgui_range
  parameters:
    label: Center Frequency - Rx
    start: '910000000'
    step: '500000'
    stop: '920000000'
    value: '915000000'
  states: {}
- name: filter_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Filter Frequency
    start: 5e4
    step: 5e4
    stop: 5e5
    value: 1e5
  states: {}
- name: filter_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,3,1,1
    label: Filter Selection
    label0: Enable
    label1: Bypass
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: gain_rx
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,2
    label: Gain - Rx
    start: '0'
    step: '5'
    stop: '60'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: avg_power_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Average Power - Observed
    min: '0'
    name: '"Average Power 1"'
    type: float
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: filter_freq + 25000
    low_cutoff_freq: filter_freq - 25000
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 5e3
    win: window.WIN_HAMMING
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: AVG_LEN
    max_iter: '500'
    scale: 1/AVG_LEN
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: filter_select
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: fc_rx
    fftsize: '1024'
    gui_hint: 1,0,1,4
    showrf: 'True'
    type: complex
  states: {}
- name: rx_addr
  id: parameter
  parameters:
    label: RX Address
    short_id: r
    type: str
    value: '3279500'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc_rx
    dev_addr: '"serial=" + rx_addr'
    dev_args: '""'
    gain0: gain_rx
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: xmlrpc_server_1
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:55555
    hwm: '1'
    timeout: '100'
    type: float
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_selector_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_moving_average_xx_0, '0', avg_power_1, '0']
- [blocks_moving_average_xx_0, '0', zeromq_pub_sink_0_0, '0']
- [blocks_selector_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_selector_0_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', blocks_selector_0_0, '1']

metadata:
  file_format: 1
