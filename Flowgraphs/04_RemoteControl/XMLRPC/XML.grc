options:
  parameters:
    author: mrahaim
    generate_options: qt_gui
    id: Hardware_Test1
    output_language: python
    title: Hardware Test 1
  states: {}

blocks:
- name: fc_rx
  id: variable_qtgui_range
  parameters:
    label: Center Frequency - Rx
    outputmsgname: value
    showports: 'False'
    start: '910000000'
    step: '1000000'
    stop: '920000000'
    value: '915000000'
  states: {}
- name: fc_tx
  id: variable_qtgui_range
  parameters:
    label: Center Frequency - Tx
    outputmsgname: value
    showports: 'False'
    start: '910000000'
    step: '1000000'
    stop: '920000000'
    value: '915000000'
  states: {}
- name: hcf
  id: variable
  parameters:
    value: '0'
  states: {}
- name: interp
  id: variable
  parameters:
    value: int(samp_rate/sig_freq)
  states: {}
- name: lcf
  id: variable
  parameters:
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000'
  states: {}
- name: sig_freq
  id: variable_qtgui_range
  parameters:
    label: Signal Frequency
    outputmsgname: value
    showports: 'False'
    start: '1000000'
    step: '1000000'
    stop: '5000000'
    value: '1000000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.25'
    freq: sig_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.25'
    freq: sig_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: hcf
    low_cutoff_freq: lcf
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: Complex Sinusoid
  states: {}
- name: note_1
  id: note
  parameters:
    note: Real Sinusoid
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Transmitter
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fc_rx
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: fc_tx
    dev_addr: '"serial=3279417"'
    dev_args: '""'
    gain0: '35'
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: fc_rx
    dev_addr: '"serial=3279500"'
    dev_args: '""'
    gain0: '40'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: TxSignal
  states: {state: disabled}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: TxSignal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: TxSignal
  states: {}
- name: xmlrpc_server_1
  id: xmlrpc_server
  parameters:
    addr: localhost
    port: '8080'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', virtual_sink_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_float_to_complex_0, '0']
- [band_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0_0_0, '0']
- [blocks_throttle_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
