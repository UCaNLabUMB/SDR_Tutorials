options:
  parameters:
    author: miguel
    description: Flowgraph using RFNoC blocks to compute FFT and stream to GNU Radio.
    generate_options: qt_gui
    id: fft_hardware
    output_language: python
    title: FFT Hardware Test
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 2.464e9
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: rfnoc_graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: '"addr=192.168.10.2"'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: RX Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: sig_freq
  id: variable_qtgui_range
  parameters:
    label: Signal Frequency
    start: 100e3
    step: 50e3
    stop: 500e3
    value: 100e3
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    start: '0'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '900e-3'
    freq: sig_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1'
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: TX
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '1'
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: uhd_rfnoc_fft_0
  id: uhd_rfnoc_fft
  parameters:
    block_args: '""'
    fft_direction: FORWARD
    fft_length: '256'
    fft_magnitude: COMPLEX
    fft_shift_config: NORMAL
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    otw: sc16
    output_type: fc32
  states: {}
- name: uhd_rfnoc_tx_streamer_0
  id: uhd_rfnoc_tx_streamer
  parameters:
    input_type: fc32
    otw: sc16
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', uhd_rfnoc_tx_streamer_0, '0']
- [uhd_rfnoc_fft_0, '0', uhd_rfnoc_rx_streamer_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_rfnoc_tx_streamer_0, '0', uhd_rfnoc_fft_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
