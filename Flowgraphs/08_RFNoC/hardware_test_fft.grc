options:
  parameters:
    author: miguel
    description: Flowgraph to interface an RFNoC FFT block with GNU Radio
    generate_options: qt_gui
    id: hardware_fft_rfnoc
    output_language: python
    title: Hardware FFT RFNoC
  states: {}

blocks:
- name: RFNoC_Graph
  id: uhd_rfnoc_graph
  parameters:
    dev_addr: '"addr=192.168.10.2"'
    dev_args: '""'
  states: {}
- name: center_frequency
  id: variable
  parameters:
    value: 2.462e9
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Receiver Gain
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sig_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,2
    label: Signal Frequency
    start: 5e4
    step: 5e4
    stop: 5e5
    value: 1e5
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Transmitter Gain
    start: '10'
    step: '1'
    stop: '50'
    value: '30'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.9'
    freq: sig_freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: fft_size
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: fft_size
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: fft_size
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: uhd_rfnoc_ddc_0
  id: uhd_rfnoc_ddc
  parameters:
    freq0: '0'
    output_rate0: samp_rate
  states: {}
- name: uhd_rfnoc_fft_0
  id: uhd_rfnoc_fft
  parameters:
    fft_direction: FORWARD
    fft_length: fft_size
    fft_magnitude: COMPLEX
    fft_shift_config: NORMAL
  states: {}
- name: uhd_rfnoc_rx_radio_0
  id: uhd_rfnoc_rx_radio
  parameters:
    antenna0: RX2
    bandwidth0: '0'
    dc_offset0: 'True'
    frequency0: center_frequency
    gain0: rx_gain
    iq_balance0: 'True'
    rate: 200e6
  states: {}
- name: uhd_rfnoc_rx_streamer_0
  id: uhd_rfnoc_rx_streamer
  parameters:
    args: '""'
    otw: sc16
    output_type: fc32
    vlen: fft_size
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_frequency
    dev_addr: '"serial=318C694"'
    dev_args: '""'
    gain0: tx_gain
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_vector_sink_f_0, '0']
- [uhd_rfnoc_ddc_0, '0', uhd_rfnoc_fft_0, '0']
- [uhd_rfnoc_fft_0, '0', uhd_rfnoc_rx_streamer_0, '0']
- [uhd_rfnoc_rx_radio_0, '0', uhd_rfnoc_ddc_0, '0']
- [uhd_rfnoc_rx_streamer_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
