options:
  parameters:
    author: Bao Trong Truong
    generate_options: qt_gui
    id: distance
    output_language: python
    title: Distance via streaming
  states: {}

blocks:
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise
    start: '0'
    step: '10e-5'
    stop: '100e-4'
    value: '10e-4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3000e3
  states: {}
- name: x1
  id: variable
  parameters:
    value: '-10'
  states: {}
- name: x2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: x3
  id: variable
  parameters:
    value: '10'
  states: {}
- name: x4
  id: variable
  parameters:
    value: '-10'
  states: {}
- name: x_ref
  id: variable_qtgui_range
  parameters:
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: y1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: y2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: y3
  id: variable
  parameters:
    value: '-10'
  states: {}
- name: y4
  id: variable
  parameters:
    value: '-10'
  states: {}
- name: y_ref
  id: variable_qtgui_range
  parameters:
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: Distance_From_Points_To_Ref_point
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Distance 1
    label2: Distance 2
    label3: Distance 3
    label4: Distance 4
    name: ''
    nconnections: '4'
    type: float
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: x_ref
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: y_ref
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: y2
    type: float
  states: {}
- name: analog_const_source_x_0_0_1
  id: analog_const_source_x
  parameters:
    const: y3
    type: float
  states: {}
- name: analog_const_source_x_0_0_2
  id: analog_const_source_x
  parameters:
    const: y4
    type: float
  states: {}
- name: analog_const_source_x_0_0_3
  id: analog_const_source_x
  parameters:
    const: x_ref - x1
    type: complex
  states: {}
- name: analog_const_source_x_0_0_3_0
  id: analog_const_source_x
  parameters:
    const: x_ref - x2
    type: complex
  states: {}
- name: analog_const_source_x_0_0_3_1
  id: analog_const_source_x
  parameters:
    const: x_ref - x3
    type: complex
  states: {}
- name: analog_const_source_x_0_0_3_2
  id: analog_const_source_x
  parameters:
    const: x_ref - x4
    type: complex
  states: {}
- name: analog_const_source_x_0_0_4
  id: analog_const_source_x
  parameters:
    const: y1
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: x2
    type: float
  states: {}
- name: analog_const_source_x_0_2
  id: analog_const_source_x
  parameters:
    const: x3
    type: float
  states: {}
- name: analog_const_source_x_0_2_3
  id: analog_const_source_x
  parameters:
    const: y_ref - y1
    type: complex
  states: {}
- name: analog_const_source_x_0_2_3_0
  id: analog_const_source_x
  parameters:
    const: y_ref - y2
    type: complex
  states: {}
- name: analog_const_source_x_0_2_3_1
  id: analog_const_source_x
  parameters:
    const: y_ref - y3
    type: complex
  states: {}
- name: analog_const_source_x_0_2_3_2
  id: analog_const_source_x
  parameters:
    const: y_ref - y4
    type: complex
  states: {}
- name: analog_const_source_x_0_3
  id: analog_const_source_x
  parameters:
    const: x4
    type: float
  states: {}
- name: analog_const_source_x_0_4
  id: analog_const_source_x
  parameters:
    const: x1
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 150e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 200e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 250e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_transcendental_0
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: blocks_transcendental_0_0
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: blocks_transcendental_0_1
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: blocks_transcendental_0_2
  id: blocks_transcendental
  parameters:
    name: sqrt
    type: float
  states: {}
- name: new_hier_1
  id: new_hier
  parameters:
    samp_rate: samp_rate
  states: {}
- name: new_hier_2
  id: new_hier
  parameters:
    samp_rate: '100'
  states: {}
- name: new_hier_3
  id: new_hier
  parameters:
    samp_rate: '100'
  states: {}
- name: new_hier_4
  id: new_hier
  parameters:
    samp_rate: '100'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Point 4
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Point 1
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Point 1
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Point 3
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: Point 3
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: Point 2
  states: {}
- name: note_0_2_0
  id: note
  parameters:
    note: Point 2
  states: {}
- name: note_0_3
  id: note
  parameters:
    note: Reference point
  states: {}
- name: note_0_3_0
  id: note
  parameters:
    note: Reference point
  states: {}
- name: note_0_4
  id: note
  parameters:
    note: Point 4
  states: {}
- name: note_2
  id: note
  parameters:
    note: observe distances from ref_point
  states: {}
- name: point_coordinate_0
  id: point_coordinate
  parameters:
    samp_rate: samp_rate
  states: {}
- name: point_coordinate_0_0
  id: point_coordinate
  parameters:
    samp_rate: samp_rate
  states: {}
- name: point_coordinate_0_1
  id: point_coordinate
  parameters:
    samp_rate: '100'
  states: {}
- name: point_coordinate_0_2
  id: point_coordinate
  parameters:
    samp_rate: samp_rate
  states: {}
- name: point_coordinate_0_3
  id: point_coordinate
  parameters:
    samp_rate: samp_rate
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    color1: '"red"'
    color3: '"red"'
    color4: '"red"'
    color5: '"green"'
    label1: Point1
    label2: Point 2
    label3: Point 3
    label4: Point 4
    label5: Reference point
    name: '"Graphic_Observation"'
    nconnections: '5'
    size: '1024'
    type: complex
    xmax: '120'
    xmin: '-120'
    ymax: '120'
    ymin: '-120'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 320e3
    fc: 200e3
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: distance_1
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: distance_2
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: distance_3
  states: {}
- name: virtual_sink_4
  id: virtual_sink
  parameters:
    stream_id: distance_4
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: distance3_sq
  states: {}
- name: virtual_sink_5_0
  id: virtual_sink
  parameters:
    stream_id: distance4_sq
  states: {}
- name: virtual_sink_5_1
  id: virtual_sink
  parameters:
    stream_id: distance1_sq
  states: {}
- name: virtual_sink_5_2
  id: virtual_sink
  parameters:
    stream_id: distance2_sq
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: distance_2
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: distance_3
  states: {}
- name: virtual_source_2_1
  id: virtual_source
  parameters:
    stream_id: distance_4
  states: {}
- name: virtual_source_2_2
  id: virtual_source
  parameters:
    stream_id: distance_1
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: distance1_sq
  states: {}
- name: virtual_source_3_0
  id: virtual_source
  parameters:
    stream_id: distance2_sq
  states: {}
- name: virtual_source_3_1
  id: virtual_source
  parameters:
    stream_id: distance3_sq
  states: {}
- name: virtual_source_3_2
  id: virtual_source
  parameters:
    stream_id: distance4_sq
  states: {}

connections:
- [analog_const_source_x_0, '0', point_coordinate_0_3, '0']
- [analog_const_source_x_0_0, '0', point_coordinate_0_3, '1']
- [analog_const_source_x_0_0_0, '0', point_coordinate_0_0, '1']
- [analog_const_source_x_0_0_1, '0', point_coordinate_0_1, '1']
- [analog_const_source_x_0_0_2, '0', point_coordinate_0_2, '1']
- [analog_const_source_x_0_0_3, '0', blocks_complex_to_mag_squared_0, '0']
- [analog_const_source_x_0_0_3_0, '0', blocks_complex_to_mag_squared_0_1, '0']
- [analog_const_source_x_0_0_3_1, '0', blocks_complex_to_mag_squared_0_2, '0']
- [analog_const_source_x_0_0_3_2, '0', blocks_complex_to_mag_squared_0_3, '0']
- [analog_const_source_x_0_0_4, '0', point_coordinate_0, '1']
- [analog_const_source_x_0_1, '0', point_coordinate_0_0, '0']
- [analog_const_source_x_0_2, '0', point_coordinate_0_1, '0']
- [analog_const_source_x_0_2_3, '0', blocks_complex_to_mag_squared_0_0, '0']
- [analog_const_source_x_0_2_3_0, '0', blocks_complex_to_mag_squared_0_0_0, '0']
- [analog_const_source_x_0_2_3_1, '0', blocks_complex_to_mag_squared_0_0_1, '0']
- [analog_const_source_x_0_2_3_2, '0', blocks_complex_to_mag_squared_0_0_2, '0']
- [analog_const_source_x_0_3, '0', point_coordinate_0_2, '0']
- [analog_const_source_x_0_4, '0', point_coordinate_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '4']
- [analog_sig_source_x_0, '0', new_hier_1, '0']
- [analog_sig_source_x_0_0, '0', new_hier_2, '0']
- [analog_sig_source_x_0_1, '0', new_hier_3, '0']
- [analog_sig_source_x_0_2, '0', new_hier_4, '0']
- [blocks_add_xx_0, '0', blocks_transcendental_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_5_1, '0']
- [blocks_add_xx_0_0, '0', blocks_transcendental_0_0, '0']
- [blocks_add_xx_0_0, '0', virtual_sink_5_2, '0']
- [blocks_add_xx_0_1, '0', blocks_transcendental_0_1, '0']
- [blocks_add_xx_0_1, '0', virtual_sink_5, '0']
- [blocks_add_xx_0_2, '0', blocks_transcendental_0_2, '0']
- [blocks_add_xx_0_2, '0', virtual_sink_5_0, '0']
- [blocks_add_xx_1, '0', qtgui_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_add_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_add_xx_0_0, '1']
- [blocks_complex_to_mag_squared_0_0_1, '0', blocks_add_xx_0_1, '1']
- [blocks_complex_to_mag_squared_0_0_2, '0', blocks_add_xx_0_2, '1']
- [blocks_complex_to_mag_squared_0_1, '0', blocks_add_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_2, '0', blocks_add_xx_0_1, '0']
- [blocks_complex_to_mag_squared_0_3, '0', blocks_add_xx_0_2, '0']
- [blocks_transcendental_0, '0', virtual_sink_1, '0']
- [blocks_transcendental_0_0, '0', virtual_sink_2, '0']
- [blocks_transcendental_0_1, '0', virtual_sink_3, '0']
- [blocks_transcendental_0_2, '0', virtual_sink_4, '0']
- [new_hier_1, '0', blocks_add_xx_1, '0']
- [new_hier_2, '0', blocks_add_xx_1, '1']
- [new_hier_3, '0', blocks_add_xx_1, '2']
- [new_hier_4, '0', blocks_add_xx_1, '3']
- [point_coordinate_0, '0', qtgui_const_sink_x_0, '0']
- [point_coordinate_0_0, '0', qtgui_const_sink_x_0, '1']
- [point_coordinate_0_1, '0', qtgui_const_sink_x_0, '2']
- [point_coordinate_0_2, '0', qtgui_const_sink_x_0, '3']
- [point_coordinate_0_3, '0', qtgui_const_sink_x_0, '4']
- [virtual_source_2, '0', Distance_From_Points_To_Ref_point, '1']
- [virtual_source_2_0, '0', Distance_From_Points_To_Ref_point, '2']
- [virtual_source_2_1, '0', Distance_From_Points_To_Ref_point, '3']
- [virtual_source_2_2, '0', Distance_From_Points_To_Ref_point, '0']
- [virtual_source_3, '0', new_hier_1, '1']
- [virtual_source_3_0, '0', new_hier_2, '1']
- [virtual_source_3_1, '0', new_hier_3, '1']
- [virtual_source_3_2, '0', new_hier_4, '1']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
