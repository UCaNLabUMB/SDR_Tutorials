options:
  parameters:
    author: Bao Trong Truong
    generate_options: hb
    id: FSPL_hier
    output_language: python
    title: FSPL Hier
  states: {}

blocks:
- name: Gv
  id: parameter
  parameters:
    value: '100'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Gv
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '1000'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: signal1
  states: {}

connections:
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_1_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
