options:
  parameters:
    generate_options: hb
    id: point_coordinate
    output_language: python
    title: point coordinate
  states: {}

blocks:
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '100'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: A
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: A
  states: {}

connections:
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_throttle2_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_float_to_complex_0, '1']
- [pad_source_1, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
