options:
  parameters:
    generate_options: no_gui
    id: Final_Packet_Error_Test_TX_B200
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: OC_high
  id: variable
  parameters:
    value: (list(range(-22, -12)),)
  states: {}
- name: OC_low
  id: variable
  parameters:
    value: (list(range(-12, -2)),)
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: packet_len
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: OC_low
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: pilot_carriers
  id: variable
  parameters:
    value: ((-15,-1),)
  states: {}
- name: pilot_symbols
  id: variable
  parameters:
    value: ((-1,1),)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: sync_word1
  id: variable
  parameters:
    value: '[0., 0., 0., 0., 0., 0., 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., -1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., -1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 1.41421356, 0., 0., 0., 0., 0., 0.]'
  states: {}
- name: sync_word2
  id: variable
  parameters:
    value: '[0j, 0j, 0j, 0j, 0j, 0j, (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1 +0j), (1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), 0j, (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (1+0j), (1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (1+0j), (-1+0j), (1+0j), (-1+0j), (-1+0j), (-1+0j), (-1+0j), 0j, 0j, 0j, 0j, 0j]'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/christopher/Desktop/DataCollection/out
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: multiply_constant_
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: range(0,20)
  states: {state: disabled}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: '64'
    header_mod: '"BPSK"'
    occupied_carriers: occupied_carriers
    packet_len_key: packet_len
    payload_mod: '"BPSK"'
    pilot_carriers: pilot_carriers
    pilot_symbols: pilot_symbols
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: gain_factor_tx
  id: parameter
  parameters:
    short_id: g
    type: intx
    value: '60'
  states: {}
- name: multiply_constant_
  id: parameter
  parameters:
    short_id: m
    type: eng_float
    value: '0.08'
  states: {}
- name: tx_addr_0
  id: parameter
  parameters:
    label: TX Address
    short_id: t
    type: str
    value: 32794C9
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX
    center_freq0: '915000000'
    dev_addr: '"serial=" + tx_addr'
    dev_args: '""'
    gain0: gain_factor_tx
    len_tag_name: ''
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
