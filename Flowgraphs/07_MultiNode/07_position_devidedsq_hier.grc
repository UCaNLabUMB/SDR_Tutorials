options:
  parameters:
    generate_options: hb
    id: devide_dsq
    output_language: python
    title: devide_dsq
  states: {}

blocks:
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_float_to_complex_1
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: samp_rate
    value: '100'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal_1
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: signal_1
  states: {}

connections:
- [analog_const_source_x_1, '0', blocks_float_to_complex_1, '1']
- [blocks_divide_xx_0, '0', virtual_sink_0, '0']
- [blocks_float_to_complex_1, '0', blocks_divide_xx_0, '1']
- [blocks_throttle2_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_divide_xx_0, '0']
- [pad_source_1, '0', blocks_float_to_complex_1, '0']
- [virtual_source_1_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
