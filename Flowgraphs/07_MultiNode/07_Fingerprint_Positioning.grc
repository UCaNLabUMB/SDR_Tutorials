options:
  parameters:
    generate_options: qt_gui
    id: Fingerprint_Positioning
    output_language: python
    title: 'Fingerprint Based Position Model '
  states: {}

blocks:
- name: F_select
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,0,1,1)
    label: Fingerprint Select
    labels: '[''F0'', ''F1'', ''F2'', ''F3'', ''F4'', ''F5'']'
    num_opts: '0'
    options: '[0, 1, 2, 3, 4, 5]'
    type: int
    value: '0'
  states: {}
- name: F_train
  id: variable
  parameters:
    value: np.column_stack((f1_vals, f2_vals, f3_vals))
  states: {}
- name: decim
  id: variable
  parameters:
    value: '3200'
  states: {}
- name: f1_vals
  id: variable
  parameters:
    value: '[0,1,2,3,4,5]'
  states: {}
- name: f2_vals
  id: variable
  parameters:
    value: '[5,4,3,2,1,0]'
  states: {}
- name: f3_vals
  id: variable
  parameters:
    value: '[3,2,4,1,5,0]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: f1_vals[F_select]
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: f3_vals[F_select]
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: f2_vals[F_select]
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_1
  id: blocks_keep_one_in_n
  parameters:
    n: decim
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    F_Train: F_train
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block - min distance fingerprinting"""

          def __init__(self, F_Train=([[1, 2, 3],[3, 5, 6]])):  # default args
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Map-Based Prediction',   # will show up in GRC
                  in_sig=[np.float32,np.float32,np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # Store the matrix as a NumPy array for convenience
              self.F_Train = np.array(F_Train)

              # Optional: validate it's actually 2D
              if self.F_Train.ndim != 2:
                  raise ValueError("Input parameter must be a 2D matrix")

              # Store shape info (often useful later)
              self.num_rows, self.num_cols = self.F_Train.shape



          def work(self, input_items, output_items):
              """Fingerprint: compare with F_Train and get argmin distance"""
              n_items = len(input_items[0])

              for i in range(n_items):
                  # Current 3D input point (i.e., F_test)
                  f0 = input_items[0][i]
                  f1 = input_items[1][i]
                  f2 = input_items[2][i]

                  d_vals = [0] * self.num_rows

                  # Loop through each row of the stored 2D matrix
                  for j in range(self.num_rows):
                      m0 = self.F_Train[j, 0]
                      m1 = self.F_Train[j, 1]
                      m2 = self.F_Train[j, 2]

                      # Euclidean distance 
                      # (ignoring the sqrt since it's irrelevant for dmin calc)
                      d_vals[j] = ((f0-m0)**2 + (f1 - m1)**2 + (f2 - m2)**2) #** 0.5

                  # Output the index of the closest row
                  output_items[0][i] = np.argmin(d_vals)

              return n_items
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,1,3,2
    label1: Value 2
    label2: Value 1
    label3: Value 0
    max: '6'
    name: '"Input Values"'
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_VERT
    gui_hint: (1,0,3,1)
    max: len(f1_vals)+1
    min: '-0.5'
    name: '"ID Selected"'
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_keep_one_in_n_0, '0']
- [analog_const_source_x_0, '0', qtgui_number_sink_0, '2']
- [analog_const_source_x_0_0, '0', blocks_keep_one_in_n_0_1, '0']
- [analog_const_source_x_0_0, '0', qtgui_number_sink_0, '0']
- [analog_const_source_x_0_1, '0', blocks_keep_one_in_n_0_0, '0']
- [analog_const_source_x_0_1, '0', qtgui_number_sink_0, '1']
- [blocks_keep_one_in_n_0, '0', epy_block_0, '0']
- [blocks_keep_one_in_n_0_0, '0', epy_block_0, '1']
- [blocks_keep_one_in_n_0_1, '0', epy_block_0, '2']
- [blocks_throttle2_0, '0', qtgui_number_sink_1, '0']
- [epy_block_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
