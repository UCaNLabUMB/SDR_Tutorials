options:
  parameters:
    author: Bao Trong Truong
    generate_options: qt_gui
    id: distancewithvariableblock_FSPL
    output_language: python
    title: distancewithvariableblock_FSPL
  states: {}

blocks:
- name: Gp1
  id: variable
  parameters:
    value: ((4*pi*f1*distance_1)/c)**2
  states: {}
- name: Gp1_dB
  id: variable
  parameters:
    value: 10*math.log10(Gp1)
  states: {}
- name: Gp2
  id: variable
  parameters:
    value: ((4*pi*f2*distance_2)/c)**2
  states: {}
- name: Gp2_dB
  id: variable
  parameters:
    value: 10*math.log10(Gp2)
  states: {}
- name: Gp3
  id: variable
  parameters:
    value: ((4*pi*f3*distance_3)/c)**2
  states: {}
- name: Gp3_dB
  id: variable
  parameters:
    value: 10*math.log10(Gp3)
  states: {}
- name: Gp4
  id: variable
  parameters:
    value: ((4*pi*f4*distance_4)/c)**2
  states: {}
- name: Gp4_dB
  id: variable
  parameters:
    value: 10*math.log10(Gp4)
  states: {}
- name: Gv1
  id: variable
  parameters:
    value: 10**(Gp1_dB/20)
  states: {}
- name: Gv2
  id: variable
  parameters:
    value: 10**(Gp2_dB/20)
  states: {}
- name: Gv3
  id: variable
  parameters:
    value: 10**(Gp3_dB/20)
  states: {}
- name: Gv4
  id: variable
  parameters:
    value: 10**(Gp4_dB/20)
  states: {}
- name: c
  id: variable
  parameters:
    value: '299792458'
  states: {}
- name: distance1_sq
  id: variable
  parameters:
    value: (x1-x_ref)**2 +(y1-y_ref)**2
  states: {}
- name: distance2_sq
  id: variable
  parameters:
    value: (x2-x_ref)**2 +(y2-y_ref)**2
  states: {}
- name: distance3_sq
  id: variable
  parameters:
    value: (x3-x_ref)**2 +(y3-y_ref)**2
  states: {}
- name: distance4_sq
  id: variable
  parameters:
    value: (x4-x_ref)**2 +(y4-y_ref)**2
  states: {}
- name: distance_1
  id: variable
  parameters:
    value: distance1_sq**(1/2)
  states: {}
- name: distance_2
  id: variable
  parameters:
    value: distance2_sq**(1/2)
  states: {}
- name: distance_3
  id: variable
  parameters:
    value: distance3_sq**(1/2)
  states: {}
- name: distance_4
  id: variable
  parameters:
    value: distance4_sq**(1/2)
  states: {}
- name: f1
  id: variable
  parameters:
    value: 100e3
  states: {}
- name: f2
  id: variable
  parameters:
    value: 150e3
  states: {}
- name: f3
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: f4
  id: variable
  parameters:
    value: 250e3
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: noise
    start: '0'
    step: '10e-5'
    stop: '100e-4'
    value: '10e-4'
  states: {}
- name: pi
  id: variable
  parameters:
    value: '3.14159265359'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: x1
  id: variable
  parameters:
    value: '-10'
  states: {}
- name: x2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: x3
  id: variable
  parameters:
    value: '10'
  states: {}
- name: x4
  id: variable
  parameters:
    value: '-10'
  states: {}
- name: x_ref
  id: variable_qtgui_range
  parameters:
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: y1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: y2
  id: variable
  parameters:
    value: '10'
  states: {}
- name: y3
  id: variable
  parameters:
    value: '-10'
  states: {}
- name: y4
  id: variable
  parameters:
    value: '-10'
  states: {}
- name: y_ref
  id: variable_qtgui_range
  parameters:
    start: '-10'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: Distance
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Distance 1
    label2: Distance 2
    label3: Distance 3
    label4: Distance 4
    name: ''
    nconnections: '4'
    type: float
  states: {}
- name: FSPL_model_0
  id: FSPL_model
  parameters:
    Gv: Gv1
    samp_rate: samp_rate
  states: {}
- name: FSPL_model_0_0
  id: FSPL_model
  parameters:
    Gv: Gv2
    samp_rate: samp_rate
  states: {}
- name: FSPL_model_0_1
  id: FSPL_model
  parameters:
    Gv: Gv3
    samp_rate: samp_rate
  states: {}
- name: FSPL_model_0_2
  id: FSPL_model
  parameters:
    Gv: Gv4
    samp_rate: samp_rate
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: distance_1
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: distance_2
    type: float
  states: {}
- name: analog_const_source_x_0_0_0
  id: analog_const_source_x
  parameters:
    const: y2
    type: float
  states: {}
- name: analog_const_source_x_0_0_1
  id: analog_const_source_x
  parameters:
    const: y3
    type: float
  states: {}
- name: analog_const_source_x_0_0_2
  id: analog_const_source_x
  parameters:
    const: y4
    type: float
  states: {}
- name: analog_const_source_x_0_0_3
  id: analog_const_source_x
  parameters:
    const: y_ref
    type: float
  states: {}
- name: analog_const_source_x_0_0_4
  id: analog_const_source_x
  parameters:
    const: y1
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: distance_3
    type: float
  states: {}
- name: analog_const_source_x_0_1_0
  id: analog_const_source_x
  parameters:
    const: x2
    type: float
  states: {}
- name: analog_const_source_x_0_2
  id: analog_const_source_x
  parameters:
    const: distance_4
    type: float
  states: {}
- name: analog_const_source_x_0_2_0
  id: analog_const_source_x
  parameters:
    const: x3
    type: float
  states: {}
- name: analog_const_source_x_0_3
  id: analog_const_source_x
  parameters:
    const: x_ref
    type: float
  states: {}
- name: analog_const_source_x_0_3_0
  id: analog_const_source_x
  parameters:
    const: x4
    type: float
  states: {}
- name: analog_const_source_x_0_4
  id: analog_const_source_x
  parameters:
    const: x1
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: Gp2_dB
    type: float
  states: {}
- name: analog_const_source_x_1_0
  id: analog_const_source_x
  parameters:
    const: Gp3_dB
    type: float
  states: {}
- name: analog_const_source_x_1_1
  id: analog_const_source_x
  parameters:
    const: Gp4_dB
    type: float
  states: {}
- name: analog_const_source_x_1_2
  id: analog_const_source_x
  parameters:
    const: Gp1_dB
    type: float
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 150e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 200e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 250e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: Point 4
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Point 1
  states: {}
- name: note_0_0_0
  id: note
  parameters:
    note: Point 1
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: Point 3
  states: {}
- name: note_0_1_0
  id: note
  parameters:
    note: Point 3
  states: {}
- name: note_0_2
  id: note
  parameters:
    note: Point 2
  states: {}
- name: note_0_2_0
  id: note
  parameters:
    note: Point 2
  states: {}
- name: note_0_3
  id: note
  parameters:
    note: Reference point
  states: {}
- name: note_0_3_0
  id: note
  parameters:
    note: Reference point
  states: {}
- name: note_0_4
  id: note
  parameters:
    note: Point 4
  states: {}
- name: note_1
  id: note
  parameters:
    note: speed of light
  states: {}
- name: note_2
  id: note
  parameters:
    note: observe distances from ref_point
  states: {}
- name: note_3
  id: note
  parameters:
    note: Power gain
  states: {}
- name: note_4
  id: note
  parameters:
    note: power gain (dB)
  states: {}
- name: note_5
  id: note
  parameters:
    note: Gv
  states: {}
- name: note_6
  id: note
  parameters:
    note: signal freq
  states: {}
- name: note_7
  id: note
  parameters:
    note: powergain(dB)
  states: {}
- name: point_coordinate_0
  id: point_coordinate
  parameters:
    samp_rate: samp_rate
  states: {}
- name: point_coordinate_0_0
  id: point_coordinate
  parameters:
    samp_rate: samp_rate
  states: {}
- name: point_coordinate_0_1
  id: point_coordinate
  parameters:
    samp_rate: samp_rate
  states: {}
- name: point_coordinate_0_2
  id: point_coordinate
  parameters:
    samp_rate: samp_rate
  states: {}
- name: point_coordinate_0_3
  id: point_coordinate
  parameters:
    samp_rate: samp_rate
  states: {}
- name: powergain_dB
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '10'
    min: '-10'
    nconnections: '4'
    type: float
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    color1: '"green"'
    color2: '"magenta"'
    color3: '"cyan"'
    color4: '"blue"'
    color5: '"red"'
    label1: Point1
    label2: Point2
    label3: Point3
    label4: Point4
    label5: Ref_point
    name: Graphic Observation
    nconnections: '5'
    size: '1024'
    type: complex
    xmax: '15'
    xmin: '-15'
    ymax: '15'
    ymin: '-15'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 320e3
    fc: 200e3
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: window.WIN_RECTANGULAR
  states: {}

connections:
- [FSPL_model_0, '0', blocks_add_xx_1, '0']
- [FSPL_model_0_0, '0', blocks_add_xx_1, '1']
- [FSPL_model_0_1, '0', blocks_add_xx_1, '2']
- [FSPL_model_0_2, '0', blocks_add_xx_1, '3']
- [analog_const_source_x_0, '0', Distance, '0']
- [analog_const_source_x_0_0, '0', Distance, '1']
- [analog_const_source_x_0_0_0, '0', point_coordinate_0_0, '1']
- [analog_const_source_x_0_0_1, '0', point_coordinate_0_1, '1']
- [analog_const_source_x_0_0_2, '0', point_coordinate_0_2, '1']
- [analog_const_source_x_0_0_3, '0', point_coordinate_0_3, '1']
- [analog_const_source_x_0_0_4, '0', point_coordinate_0, '1']
- [analog_const_source_x_0_1, '0', Distance, '2']
- [analog_const_source_x_0_1_0, '0', point_coordinate_0_0, '0']
- [analog_const_source_x_0_2, '0', Distance, '3']
- [analog_const_source_x_0_2_0, '0', point_coordinate_0_1, '0']
- [analog_const_source_x_0_3, '0', point_coordinate_0_3, '0']
- [analog_const_source_x_0_3_0, '0', point_coordinate_0_2, '0']
- [analog_const_source_x_0_4, '0', point_coordinate_0, '0']
- [analog_const_source_x_1, '0', powergain_dB, '1']
- [analog_const_source_x_1_0, '0', powergain_dB, '2']
- [analog_const_source_x_1_1, '0', powergain_dB, '3']
- [analog_const_source_x_1_2, '0', powergain_dB, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_1, '4']
- [analog_sig_source_x_0, '0', FSPL_model_0, '0']
- [analog_sig_source_x_0_0, '0', FSPL_model_0_0, '0']
- [analog_sig_source_x_0_1, '0', FSPL_model_0_1, '0']
- [analog_sig_source_x_0_2, '0', FSPL_model_0_2, '0']
- [blocks_add_xx_1, '0', qtgui_sink_x_0, '0']
- [point_coordinate_0, '0', qtgui_const_sink_x_0, '0']
- [point_coordinate_0_0, '0', qtgui_const_sink_x_0, '1']
- [point_coordinate_0_1, '0', qtgui_const_sink_x_0, '2']
- [point_coordinate_0_2, '0', qtgui_const_sink_x_0, '3']
- [point_coordinate_0_3, '0', qtgui_const_sink_x_0, '4']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
